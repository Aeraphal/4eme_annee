# Keil uVision project BSE_TP6.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: BSE_TP6
  c flags: SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 TP6_BSE_Main.OBJ
